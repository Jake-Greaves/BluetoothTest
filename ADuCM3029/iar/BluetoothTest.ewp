# IAR project BluetoothTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\inc\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BluetoothTest.hex
  ILINK.IlinkOutputFile: BluetoothTest.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BluetoothTest.srec
  group (top)
    ../../: ADuCM3029_Sleep_Interface.c ADuCM3029_Timer_Interface.c App_Interface.c LibIIO_Interface.c LibIIO_Utility.c main.c Placeholder_TempInterface.c
    ../: pinMuxBLE.c
  group BLE Module
    ../../: BLE_Module.c Communications.c
  group BLE Source
    ../../: Wireless_Sense_Module.h
  group Source
    ../../src/dma/: adi_dma.c
    ../../src/gpio/: adi_gpio.c
    ../../src/pwr/: adi_pwr.c
    ../../src/spi/: adi_spi.c
    ../../src/tmr/: adi_tmr.c
    ../../src/uart/: adi_uart.c
    ../../src/wdt/: adi_wdt.c
    ../../src/: common.c startup.c system.c
